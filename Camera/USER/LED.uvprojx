# Keil uVision project LED.uvprojx, settings and files
target LED (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\ADC;..\HARDWARE\Balence;..\HARDWARE\DCMI;..\HARDWARE\Exti;..\HARDWARE\IIC;..\HARDWARE\isr;..\HARDWARE\key;..\HARDWARE\LED;..\HARDWARE\LedBuz;..\HARDWARE\Mpu6050;..\HARDWARE\MyNvic;..\HARDWARE\OLED;..\HARDWARE\Pwm;..\HARDWARE\QEI;..\HARDWARE\RTC;..\HARDWARE\taskcontrol;..\HARDWARE\TeeterBoard;..\HARDWARE\Timer;..\HARDWARE\UartLink;..\HARDWARE\VoiceDis;..\HARDWARE;..\HARDWARE\key;..\HARDWARE\ultrasonic;..\HARDWARE\NRF24L01;..\HARDWARE\NRF24L01;..\HARDWARE\Out_thr
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DCMI/: DCMI.c DealCamera.c
    ../HARDWARE/LedBuz/: LedBuz.c
    ../HARDWARE/MyNvic/: MyNvic.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/Pwm/: pwm.c
    ../HARDWARE/QEI/: QEI.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/UartLink/: UartLink.c ANO_Uart.c datatransfor.c
    ../HARDWARE/Timer/: Timer.c
    ../HARDWARE/key/: key_matrix.c key2oled.c
    ../HARDWARE/ultrasonic/: ultrasonic.c Kalman.c
    ../HARDWARE/NRF24L01/: nrf24l01.c
    ./: RC.c
    ../HARDWARE/Mpu6050/: softdrive_mpu6050.c Ano_I2c.c imu.c mymath.c Ano_I2c_2.c softdrive_mpu6050_2.c imu_2.c
    ../HARDWARE/Out_thr/: Out_thr.c
    ../HARDWARE/: MyTask.c absoluteEncoder.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c
